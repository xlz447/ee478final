<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Hand.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\Helicopter\Helicopter.ewp</path>
  </project>
  <batchBuild/>
</workspace>


