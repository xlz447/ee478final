# IAR project Helicopter.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: Source\; Source\ds18b20; Source\mpl3115a2; Source\flex adc; Source\btUART; Source\timer
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f2274.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../Hand/Source/: delay.h
    Source/: main.c main.h
  group ds18b20
    Source/ds18b20/: ds18x20.c ds18x20.h ishan.c ishan.h
  group flex adc
    Source/flex adc/: flex_adc.c flex_adc.h
  group timer
    Source/timer/: timer.c timer.h
  group Uart/Bluetooth
    Source/btUART/: btUART.c btUART.h
